# Keil uVision project w600_demo.uvprojx, settings and files
target w600_demo (6120000::V6.12::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: w600_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: _MSC_VER __WinnerMicro__ __W600__
  c misc: -fms-extensions -Wno-empty-body -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\..\vsf;..\..\usrapp\w600_demo
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group usrapp
    ../../usrapp/w600_demo/: main.c vsf_app_cfg.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h
  group vsf/kernel/task
    ../../../vsf/kernel/task/: vsf_fsm.h vsf_pt.h vsf_task.c vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/hal/arch
    ../../../vsf/hal/arch/: vsf_arch.c vsf_arch.h vsf_arch_abstraction.h
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_io.h vsf_interface_pm.h
  group vsf/hal/driver
    ../../../vsf/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/: common.c common.h
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup/MDK/: startup_venus.s
  group vsf/utilities/template
    ../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_heap.c vsf_heap.h vsf_list.c vsf_list.h vsf_pool.c vsf_pool.h
  group vsf/utilities
    ../../../vsf/utilities/: communicate.h compiler.h ooc.h ooc_class.h ooc_class_new.h ooc_class_simple.h ooc_class_strict.h type.h
  group vsf/compiler
    ../../../vsf/utilities/compiler/arm/: signal.h signal.c arm_compiler.h
software components: CMSIS:CORE 5.2.0

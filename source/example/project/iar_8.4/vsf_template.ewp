# IAR project vsf_template.ewp, settings and files
configuration arm_mps2_m7 (ARM, debug)
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CMSDK_CM7_SP; __MPS2__; __ARM__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866,Pe064
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM7\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vsf_template.hex
  ILINK.IlinkOutputFile: vsf_template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration kernel_template_cm7 (ARM, debug)
  as the first configuration, except:
  General.FPU2: 6
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM7\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
configuration kernel_lib_armv7m_full_size (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: CMSDK_CM7; __MPS2__; __ARM__; __VSF_LIB__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: as above
  postbuild: C:\Keil_v5\ARM\ARMCLANG\bin\armar.exe -s kernel_lib\vsf_kernel_armv7m_full_size.a
configuration kernel_lib_armv6m_full_size (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CortexM0MPS2FVP Cortex-M0 MPS2 FVP
  General.CoreVariant: 34
  ICCARM.CCDefines: CMSDK_CM0; __MPS2__; __ARM__; __VSF_LIB__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM0\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  postbuild: C:\Keil_v5\ARM\ARMCLANG\bin\armar.exe -s kernel_lib\vsf_kernel_armv6m_full_size.a
configuration usbh_m484 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866,Pa082
  ICCARM.CCIncludePath2: ..\..\usrapp\usbh_demo; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
configuration WinnerMicro_W600 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 38
  ICCARM.CCDefines: __WinnerMicro__; __W600__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: ..\..\usrapp\w600_demo; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include
  ILINK.IlinkIcfFile: W600.icf
  ILINK.IlinkExtraOptions: --no_entry
configuration aio_m484 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866,Pa082,Pe111
  ICCARM.CCIncludePath2: ..\..\usrapp\aio_demo; ..\..\usrapp\aio_demo\config; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\vsf\component\3rd-party\btstack\raw\src; ..\..\..\vsf\component\3rd-party\btstack\raw\chipset\csr; ..\..\..\vsf\component\3rd-party\lwip\1.4.1\raw\src\include; ..\..\..\vsf\component\3rd-party\lwip\1.4.1\raw\src\include\ipv4; ..\..\..\vsf\component\3rd-party\lwip\1.4.1\port; ..\..\..\vsf\component\3rd-party\nnom\raw\inc; ..\..\..\vsf\component\3rd-party\nnom\port; ..\..\..\vsf\component\3rd-party\littlevgl\6.0\raw
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
configuration kernel_lib_armv7em_full_size (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CMSDK_CM7_SP; __MPS2__; __ARM__; __VSF_LIB__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866
  ICCARM.CCIncludePath2: as above
  postbuild: C:\Keil_v5\ARM\ARMCLANG\bin\armar.exe -s kernel_lib\vsf_kernel_armv7em_full_size.a
configuration nes_simulator (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__; LV_CONF_INCLUDE_SIMPLE; JEG_USE_EXTERNAL_DRAW_PIXEL_INTERFACE=ENABLED; JEG_USE_FRAME_SYNC_UP_FLAG=ENABLED; JEG_MAX_ALLOWED_SPRITES_ON_SINGLE_SCANLINE=32; JEG_USE_EXTRA_16BIT_BUS_ACCESS=ENABLED; JEG_USE_DMA_MEMORY_COPY_ACCELERATION=ENABLED
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866,Pa082,Pe111
  ICCARM.CCIncludePath2: ..\..\usrapp\nes_simulator; ..\..\usrapp\nes_simulator\config; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration arm_mps2_m0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CortexM0MPS2FVP Cortex-M0 MPS2 FVP
  General.CoreVariant: 34
  ICCARM.CCDefines: CMSDK_CM0; __MPS2__; __ARM__
  ICCARM.CCIncludePath2: C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Device\CMSDK_CM0\Include; C:\Keil_v5\ARM\PACK\Keil\V2M-MPS2_CMx_BSP\1.7.0\Boards\ARM\V2M-MPS2\Common; C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\Device\ARM\; ..\..\usrapp\template; ..\..\..\vsf
configuration kernel_test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: as above
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __Nuvoton__; __M484__
  ICCARM.CCDiagSuppress: Pe186,Pe111,pe301,pe128,pe381,Pe188,Pe1866,Pa082,Pe111
  ICCARM.CCIncludePath2: ..\..\usrapp\kernel_test; ..\..\..\vsf; ..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\DSP\Include; ..\..\..\vsf\utilities\compiler\arm\CMSIS\NN\Include
  ILINK.IlinkIcfFile: m480.icf
  ILINK.IlinkExtraOptions: --no_entry
  group (top)
    ../../../vsf/kernel/lib/: vsf_kernel_armv6m_full_size.a vsf_kernel_armv7m_full_size.a
    kernel_lib/: vsf_kernel_armv7em_full_size.a
  group usrapp/aio_demo
    ../../usrapp/aio_demo/: ai_demo.c bt_demo.c input_demo.c main.c systimer_test.c tcpip_demo.c ui_demo.c usbd_demo.c usbh_demo.c
    ../../../vsf/component/3rd-party/btstack/raw/example/: gap_inquiry.c
  group usrapp/aio_demo/ao_model/mnist
    ../../usrapp/aio_demo/ai_model/mnist/: image.h weights.h
  group usrapp/aio_demo/config
    ../../usrapp/aio_demo/config/: btstack_config.h lv_conf.h lwipopts.h vsf_usr_cfg.h
  group usrapp/kernel_test
    ../../usrapp/kernel_test/: main.c mutex_test.c queue_test.c sem_test.c vsf_usr_cfg.h
  group usrapp/nes_simulator
    ../../usrapp/nes_simulator/: main.c ui_demo.c ui_demo_trans_uvc.c
  group usrapp/nes_simulator/config
    ../../usrapp/nes_simulator/config/: vsf_usr_cfg.h
  group usrapp/nes_simulator/simulator
    ../../usrapp/nes_simulator/simulator/: simulator.c
  group usrapp/nes_simulator/simulator/jeg
    ../../usrapp/nes_simulator/simulator/jeg/: cartridge.c cartridge.h common.h cpu6502.c cpu6502.h cpu6502_opcodes.c cpu6502_opcodes.h fce.c fce.h hal.h jeg_cfg.h nes.c nes.h ppu.h ppu_pixel_based.c
  group usrapp/nes_simulator/simulator/rom
    ../../usrapp/nes_simulator/simulator/rom/: battle_city.c contra.c road_fighter.c super_mario_broes.c
  group usrapp/template
    ../../usrapp/template/: main.c user_retarget.c vsf_usr_cfg.h
  group usrapp/template/ooc_demo
    ../../usrapp/template/ooc_demo/: __class_demo.h class_demo.c class_demo.h class_simple_demo.c class_simple_demo.h
  group usrapp/ui_demo
    ../../usrapp/ui_demo/: lv_conf.h main.c ui_demo.c ui_demo_trans_uvc.c vsf_usr_cfg.h
  group usrapp/usbh_demo
    ../../usrapp/usbh_demo/: cdc_stream_demo.c main.c vsf_usr_cfg.h
  group usrapp/w600_demo
    ../../usrapp/w600_demo/: main.c vsf_usr_cfg.h
  group vsf
    ../../../vsf/: vsf.h vsf_cfg.h
  group vsf/component
    ../../../vsf/component/: vsf_component.c vsf_component.h vsf_component_cfg.h
  group vsf/component/3rd-party/btstack/port
    ../../../vsf/component/3rd-party/btstack/port/: btstack_run_loop_vsf.c btstack_run_loop_vsf.h hci_dump_vsf.c hci_transport_h2_vsf.c
  group vsf/component/3rd-party/btstack/raw/chipset/csr
    ../../../vsf/component/3rd-party/btstack/raw/chipset/csr/: btstack_chipset_csr.c
  group vsf/component/3rd-party/btstack/raw/src
    ../../../vsf/component/3rd-party/btstack/raw/src/: ad_parser.c btstack_linked_list.c btstack_memory.c btstack_memory_pool.c btstack_run_loop.c btstack_util.c hci.c hci_cmd.c l2cap.c l2cap_signaling.c
  group vsf/component/3rd-party/btstack/raw/src/classic
    ../../../vsf/component/3rd-party/btstack/raw/src/classic/: hid_device.c rfcomm.c sdp_server.c sdp_util.c spp_server.c
  group vsf/component/3rd-party/littlevgl/6.0/raw
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/: lvgl.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/: lv_conf_checker.h lv_version.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_core
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_core/: lv_disp.c lv_disp.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_draw
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_basic.c lv_draw_basic.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_font
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_font/: lv_font.c lv_font.h lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c lv_symbol_def.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_hal
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_misc
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_types.h lv_utils.c lv_utils.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_objx
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_canvas.c lv_canvas.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_spinbox.c lv_spinbox.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_table.c lv_table.h lv_tabview.c lv_tabview.h lv_tileview.c lv_tileview.h lv_win.c lv_win.h
  group vsf/component/3rd-party/littlevgl/6.0/raw/src/lv_themes
    ../../../vsf/component/3rd-party/littlevgl/6.0/raw/lvgl/src/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h
  group vsf/component/3rd-party/lwip/1.4.1/port
    ../../../vsf/component/3rd-party/lwip/1.4.1/port/: lwip_netdrv_adapter.c lwip_netdrv_adapter.h lwippools.h
  group vsf/component/3rd-party/lwip/1.4.1/port/arch
    ../../../vsf/component/3rd-party/lwip/1.4.1/port/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/api
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv4
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv6
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/core/snmp
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group vsf/component/3rd-party/lwip/1.4.1/raw/src/netif
    ../../../vsf/component/3rd-party/lwip/1.4.1/raw/src/netif/: etharp.c
  group vsf/component/3rd-party/nnom/port
    ../../../vsf/component/3rd-party/nnom/port/: nnom_port.h
  group vsf/component/3rd-party/nnom/raw/inc
    ../../../vsf/component/3rd-party/nnom/raw/inc/: nnom.h nnom_activations.h nnom_layers.h nnom_local.h nnom_out_shape.h nnom_run.h nnom_utils.h
  group vsf/component/3rd-party/nnom/raw/src
    ../../../vsf/component/3rd-party/nnom/raw/src/: nnom.c nnom_activations.c nnom_layers.c nnom_local.c nnom_out_shape.c nnom_run.c nnom_utils.c
  group vsf/component/av
    ../../../vsf/component/av/: vsfav.h
  group vsf/component/input
    ../../../vsf/component/input/: vsf_input.c vsf_input.h vsf_input_cfg.h
  group vsf/component/input/driver/ds4
    ../../../vsf/component/input/driver/ds4/: vsf_input_ds4.c vsf_input_ds4.h
  group vsf/component/input/driver/hid
    ../../../vsf/component/input/driver/hid/: vsf_input_hid.c vsf_input_hid.h
  group vsf/component/input/protocol
    ../../../vsf/component/input/protocol/: vsf_input_gamepad.h vsf_input_sensor.h
  group vsf/component/tcpip
    ../../../vsf/component/tcpip/: vsf_tcpip_cfg.h
  group vsf/component/tcpip/netdrv
    ../../../vsf/component/tcpip/netdrv/: vsf_netdrv.c vsf_netdrv.h
  group vsf/component/usb
    ../../../vsf/component/usb/: vsf_usb_cfg.h
  group vsf/component/usb/common
    ../../../vsf/component/usb/common/: usb_ch11.h usb_ch9.h usb_common.h usb_type.h
  group vsf/component/usb/common/class/CDC
    ../../../vsf/component/usb/common/class/CDC/: vsf_usb_CDC.h vsf_usb_CDCACM.h
  group vsf/component/usb/common/class/HID
    ../../../vsf/component/usb/common/class/HID/: vsf_usb_ds4.h vsf_usb_HID.h
  group vsf/component/usb/common/class/UVC
    ../../../vsf/component/usb/common/class/UVC/: vsf_usb_UVC.h
  group vsf/component/usb/device
    ../../../vsf/component/usb/device/: vsf_usbd.c vsf_usbd.h
  group vsf/component/usb/device/class/CDC
    ../../../vsf/component/usb/device/class/CDC/: vsf_usbd_CDC.c vsf_usbd_CDC.h vsf_usbd_CDCACM.c vsf_usbd_CDCACM.h
  group vsf/component/usb/device/class/HID
    ../../../vsf/component/usb/device/class/HID/: vsf_usbd_HID.c vsf_usbd_HID.h
  group vsf/component/usb/device/class/UVC
    ../../../vsf/component/usb/device/class/UVC/: vsf_usbd_UVC.c vsf_usbd_UVC.h
  group vsf/component/usb/driver/hcd/ohci
    ../../../vsf/component/usb/driver/hcd/ohci/: vsf_ohci.c vsf_ohci.h
  group vsf/component/usb/driver/otg/musb/fdrc
    ../../../vsf/component/usb/driver/otg/musb/fdrc/: __vsf_musb_fdrc_common.c __vsf_musb_fdrc_common.h vsf_musb_fdrc_dcd.c vsf_musb_fdrc_dcd.h
  group vsf/component/usb/host
    ../../../vsf/component/usb/host/: vsf_usbh.c vsf_usbh.h
  group vsf/component/usb/host/class/BTHCI
    ../../../vsf/component/usb/host/class/BTHCI/: vsf_usbh_BTHCI.c vsf_usbh_BTHCI.h
  group vsf/component/usb/host/class/CDC
    ../../../vsf/component/usb/host/class/CDC/: vsf_usbh_CDC.c vsf_usbh_CDC.h vsf_usbh_CDCECM.c vsf_usbh_CDCECM.h
  group vsf/component/usb/host/class/HID
    ../../../vsf/component/usb/host/class/HID/: vsf_usbh_ds4.c vsf_usbh_ds4.h vsf_usbh_HID.c vsf_usbh_HID.h
  group vsf/component/usb/host/class/HUB
    ../../../vsf/component/usb/host/class/HUB/: vsf_usbh_HUB.c vsf_usbh_HUB.h
  group vsf/component/usb/host/class/libusb
    ../../../vsf/component/usb/host/class/libusb/: vsf_usbh_libusb.c vsf_usbh_libusb.h
  group vsf/hal
    ../../../vsf/hal/: vsf_hal.c vsf_hal.h vsf_hal_cfg.h
  group vsf/hal/arch
    ../../../vsf/hal/arch/: vsf_arch.h vsf_arch_abstraction.c vsf_arch_abstraction.h
  group vsf/hal/arch/arm/cortex-m
    ../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick.h systick_internal.c systick_internal.h
  group vsf/hal/driver
    ../../../vsf/hal/driver/: driver.h
  group vsf/hal/driver/arm
    ../../../vsf/hal/driver/arm/: driver.h
  group vsf/hal/driver/arm/mps2
    ../../../vsf/hal/driver/arm/mps2/: __device.h driver.h
  group vsf/hal/driver/arm/mps2/CMSDK_CM0
    ../../../vsf/hal/driver/arm/mps2/CMSDK_CM0/: device.h driver.c driver.h startup_ARMCM0.c
  group vsf/hal/driver/arm/mps2/CMSDK_CM7
    ../../../vsf/hal/driver/arm/mps2/CMSDK_CM7/: device.h driver.c driver.h startup_ARMCM7.c
  group vsf/hal/driver/arm/mps2/common
    ../../../vsf/hal/driver/arm/mps2/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton
    ../../../vsf/hal/driver/Nuvoton/: driver.h
  group vsf/hal/driver/Nuvoton/M480
    ../../../vsf/hal/driver/Nuvoton/M480/: __device.h
  group vsf/hal/driver/Nuvoton/M480/common
    ../../../vsf/hal/driver/Nuvoton/M480/common/: __common.c __common.h
  group vsf/hal/driver/Nuvoton/M480/common/io
    ../../../vsf/hal/driver/Nuvoton/M480/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/pm
    ../../../vsf/hal/driver/Nuvoton/M480/common/pm/: pm.c pm.h pm_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usart
    ../../../vsf/hal/driver/Nuvoton/M480/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/: usb.c usb.h usb_lv0.c
  group vsf/hal/driver/Nuvoton/M480/common/usb/dc
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/dc/: usbd_hs.c usbd_hs.h
  group vsf/hal/driver/Nuvoton/M480/common/usb/ohci
    ../../../vsf/hal/driver/Nuvoton/M480/common/usb/ohci/: ohci.c ohci.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/Include
    ../../../vsf/hal/driver/Nuvoton/M480/common/vendor/Include/: acmp_reg.h bpwm_reg.h can_reg.h clk_reg.h crc_reg.h crypto_reg.h dac_reg.h eadc_reg.h ebi_reg.h ecap_reg.h emac_reg.h epwm_reg.h fmc_reg.h gpio_reg.h hsotg_reg.h hsusbd_reg.h hsusbh_reg.h i2c_reg.h i2s_reg.h M480.h NuMicro.h opa_reg.h otg_reg.h pdma_reg.h qei_reg.h qspi_reg.h rtc_reg.h sc_reg.h sdh_reg.h spi_reg.h spim_reg.h sys_reg.h system_M480.h timer_reg.h uart_reg.h ui2c_reg.h usbd_reg.h usbh_reg.h uspi_reg.h uuart_reg.h wdt_reg.h wwdt_reg.h
  group vsf/hal/driver/Nuvoton/M480/common/vendor/startup
    ../../../vsf/hal/driver/Nuvoton/M480/common/vendor/startup/IAR/: startup_M480.s.template
  group vsf/hal/driver/Nuvoton/M480/M484
    ../../../vsf/hal/driver/Nuvoton/M480/M484/: device.h driver.c driver.h startup_M484.c
  group vsf/hal/driver/Nuvoton/NuConsole
    ../../../vsf/hal/driver/Nuvoton/NuConsole/: NuConsole.c NuConsole.h NuConsole_Config.h NuConsole_stream.c
  group vsf/hal/driver/template
    ../../../vsf/hal/driver/template/: driver.h
  group vsf/hal/driver/template/__series_name__/__device_name_1__
    ../../../vsf/hal/driver/template/__series_name__/__device_name_1__/: driver.c driver.h
  group vsf/hal/driver/WinnerMicro
    ../../../vsf/hal/driver/WinnerMicro/: driver.h
  group vsf/hal/driver/WinnerMicro/W60X
    ../../../vsf/hal/driver/WinnerMicro/W60X/: device.h
  group vsf/hal/driver/WinnerMicro/W60X/common
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/: common.c common.h
  group vsf/hal/driver/WinnerMicro/W60X/common/io
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/io/: io.c io.h io_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/usart
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/usart/: usart.c usart.h usart_lv0.c
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/Include/: wm_regs.h
  group vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup
    ../../../vsf/hal/driver/WinnerMicro/W60X/common/vendor/startup/IAR/: startup_venus.s
  group vsf/hal/driver/WinnerMicro/W60X/W600
    ../../../vsf/hal/driver/WinnerMicro/W60X/W600/: device.h driver.c driver.h
  group vsf/hal/interface
    ../../../vsf/hal/interface/: vsf_interface_common.h vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h
  group vsf/kernel
    ../../../vsf/kernel/: vsf_eda.c vsf_eda.h vsf_evtq.h vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_bsp.c vsf_kernel_cfg.h vsf_kernel_common.h vsf_os.c vsf_os.h vsf_queue.c vsf_queue.h vsf_timq.h vsf_timq_dlist.h
  group vsf/kernel/shell
    ../../../vsf/kernel/shell/: vsf_shell.c
  group vsf/kernel/shell/simple
    ../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.c vsf_simple_task.c
  group vsf/kernel/task
    ../../../vsf/kernel/task/: __vsf_task_common.h vsf_fsm.h vsf_pt.h vsf_task.h vsf_thread.c vsf_thread.h
  group vsf/service
    ../../../vsf/service/: vsf_service.c vsf_service.h vsf_service_cfg.h
  group vsf/service/dynarr
    ../../../vsf/service/dynarr/: vsf_dynarr.c vsf_dynarr.h
  group vsf/service/dynstack
    ../../../vsf/service/dynstack/: vsf_dynstack.c vsf_dynstack.h
  group vsf/service/heap
    ../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/service/json
    ../../../vsf/service/json/: vsf_json.c vsf_json.h
  group vsf/service/pool
    ../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service/stream
    ../../../vsf/service/stream/: interface.h vsf_stream.c vsf_stream.h vsf_stream_base.c vsf_stream_base.h vsf_stream_reader.c vsf_stream_reader.h vsf_stream_writer.c vsf_stream_writer.h
  group vsf/service/stream/pbuf
    ../../../vsf/service/stream/pbuf/: vsf_pbuf.c vsf_pbuf.h vsf_pbuf_pool.c vsf_pbuf_pool.h
  group vsf/service/stream/pbuf_queue
    ../../../vsf/service/stream/pbuf_queue/: vsf_pbuf_queue.c vsf_pbuf_queue.h
  group vsf/service/trace
    ../../../vsf/service/trace/: vsf_trace.c vsf_trace.h
  group vsf/service/vsfstream
    ../../../vsf/service/vsfstream/: vsfstream.c vsfstream.h
  group vsf/service/vsfstream/fifo_stream
    ../../../vsf/service/vsfstream/fifo_stream/: vsf_fifo_stream.c vsf_fifo_stream.h
  group vsf/utilities
    ../../../vsf/utilities/: communicate.h compiler.h ooc_class.h type.h
  group vsf/utilities/3rd-party/PLOOC
    ../../../vsf/utilities/3rd-party/PLOOC/: plooc.h plooc_class.h plooc_class_black_box.h plooc_class_simple.h plooc_class_strict.h README.md
  group vsf/utilities/compiler
    ../../../vsf/utilities/compiler/arm/: arm_compiler.h retarget_io.c signal.c signal.h vsf_stdio_lib.a
  group vsf/utilities/compiler/CMSIS/DSP/Include
    ../../../vsf/utilities/compiler/arm/CMSIS/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group vsf/utilities/compiler/CMSIS/NN/Include
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group vsf/utilities/compiler/CMSIS/NN/source/ActivationFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
  group vsf/utilities/compiler/CMSIS/NN/source/ConvolutionFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c
  group vsf/utilities/compiler/CMSIS/NN/source/FullyConnectedFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c
  group vsf/utilities/compiler/CMSIS/NN/source/NNSupportFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_add_q7.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_with_offset.c
  group vsf/utilities/compiler/CMSIS/NN/source/PoolingFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group vsf/utilities/compiler/CMSIS/NN/source/SoftmaxFunctions
    ../../../vsf/utilities/compiler/arm/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group vsf/utilities/language_extension
    ../../../vsf/utilities/language_extension/: code_region.c code_region.h language_extension.h
  group vsf/utilities/preprocessor
    ../../../vsf/utilities/preprocessor/: mf_u8_dec2str.h mrepeat.h preprocessor.h tpaste.h
  group vsf/utilities/template
    ../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h
